# Keil uVision project ble_simple_peripheral.uvprojx, settings and files
target ble_simple_peripheral (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: D:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe  --text  -c -o Output/ble_simple_peripheral.txt  Objects/ble_simple_peripheral.axf
  AfterMake: D:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\components\ble\include;.\components\ble\include\gap;.\components\ble\include\gatt;.\components\ble\profiles\ble_simple_profile;..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_simple_profile;..\code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ./code/: proj_main.c ble_simple_peripheral.c ble_simple_peripheral.h user_task.c base_ble.c base_ble.h protocol.c protocol_fe.c protocol_fe.h protocol_fd.c protocol_fd.h protocol_cmd.h ble_function.h ble_function.c flash_usage_config.h user_task.h usart_device.c scanner.c scanner.h TPMS.c TPMS.h rssi_check.c rssi_check.h usart_cmd.h phone_reply.c phone_reply.h
    ../../../../components/modules/button/: button.c
    ./: protocol.h usart_device.h
    ../code/: flash_op.c flash_op.h tpms_demo.c tpms_logic.c en_de_algo.c en_de_algo.h param_sync.c param_sync.h protocol_01.c scanner_example.c CMD_define.h fliash_op.h proto_time6_bcd.h protocol_01.h tpms_demo.h tpms_logic.h
    ./components/modules/aes_cbc/: aes_cbc.c aes_cbc.h
  group profiles
    ./components/ble/profiles/ble_simple_profile/: simple_gatt_service.c simple_gatt_service.h
  group driver
    ../../../../components/driver/: driver_iic.c driver_pmu.c driver_keyscan.c driver_pmu_qdec.c driver_rtc.c driver_uart.c driver_wdt.c driver_i2s.c driver_exti.c driver_timer.c driver_efuse.c
  group platform
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../../components/modules/patch/: patch.c
  group lib
    ../../../../components/ble/library/: fr8010h_stack.lib
